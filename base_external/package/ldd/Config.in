## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes the ldd modules from misc-modules and scull as cross-compiled kernel modules
```
